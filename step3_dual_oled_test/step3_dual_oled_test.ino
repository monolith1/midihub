/*
 * ==============================================================================
 * Step 3: Dual 0.96" I2C OLED Hardware Test (Zero-Jumper Mod, Pure Self-Contained)
 * ==============================================================================
 * 
 * Wire Hookup:
 * 
 *   SCREEN 1 (Left - Parameters / HUD):
 *     GND ──► ESP32 GND
 *     VCC ──► ESP32 3V3
 *     SCL ──► ESP32 GPIO 12  (I2C Bus 0)
 *     SDA ──► ESP32 GPIO 11  (I2C Bus 0)
 * 
 *   SCREEN 2 (Right - Visualizer / Waves):
 *     GND ──► ESP32 GND
 *     VCC ──► ESP32 3V3
 *     SCL ──► ESP32 GPIO 9   (I2C Bus 1)
 *     SDA ──► ESP32 GPIO 10  (I2C Bus 1)
 * 
 * Both screens stay at factory default address 0x3C!
 * No external libraries needed: Native I2C + SSD1306 framebuffer included!
 */

#include <Arduino.h>
#include <Wire.h>

#define OLED_ADDR 0x3C
#define OLED_WIDTH 128
#define OLED_HEIGHT 64

// Screen 1: Bus 0 (Wire)
#define S1_SDA 11
#define S1_SCL 12

// Screen 2: Bus 1 (Wire1)
#define S2_SDA 10
#define S2_SCL 9

// Framebuffers (128x64 / 8 = 1024 bytes each)
static uint8_t fb1[1024];
static uint8_t fb2[1024];

// Compact 5x7 ASCII Font (32 ' ' to 126 '~')
static const uint8_t FONT5x7[][5] PROGMEM = {
  {0x00,0x00,0x00,0x00,0x00},{0x00,0x00,0x5F,0x00,0x00},{0x00,0x07,0x00,0x07,0x00},{0x14,0x7F,0x14,0x7F,0x14},
  {0x24,0x2A,0x7F,0x2A,0x12},{0x23,0x13,0x08,0x64,0x62},{0x36,0x49,0x55,0x22,0x50},{0x00,0x05,0x03,0x00,0x00},
  {0x00,0x1C,0x22,0x41,0x00},{0x00,0x41,0x22,0x1C,0x00},{0x14,0x08,0x3E,0x08,0x14},{0x08,0x08,0x3E,0x08,0x08},
  {0x00,0x50,0x30,0x00,0x00},{0x08,0x08,0x08,0x08,0x08},{0x00,0x60,0x60,0x00,0x00},{0x20,0x10,0x08,0x04,0x02},
  {0x3E,0x51,0x49,0x45,0x3E},{0x00,0x42,0x7F,0x40,0x00},{0x42,0x61,0x51,0x49,0x46},{0x21,0x41,0x45,0x4B,0x31},
  {0x18,0x14,0x12,0x7F,0x10},{0x27,0x45,0x45,0x45,0x39},{0x3C,0x4A,0x49,0x49,0x30},{0x01,0x71,0x09,0x05,0x03},
  {0x36,0x49,0x49,0x49,0x36},{0x06,0x49,0x49,0x29,0x1E},{0x00,0x36,0x36,0x00,0x00},{0x00,0x56,0x36,0x00,0x00},
  {0x08,0x14,0x22,0x41,0x00},{0x14,0x14,0x14,0x14,0x14},{0x00,0x41,0x22,0x14,0x08},{0x02,0x01,0x51,0x09,0x06},
  {0x32,0x49,0x79,0x41,0x3E},{0x7E,0x11,0x11,0x11,0x7E},{0x7F,0x49,0x49,0x49,0x36},{0x3E,0x41,0x41,0x41,0x22},
  {0x7F,0x41,0x41,0x22,0x1C},{0x7F,0x49,0x49,0x49,0x41},{0x7F,0x09,0x09,0x09,0x01},{0x3E,0x41,0x49,0x49,0x7A},
  {0x7F,0x08,0x08,0x08,0x7F},{0x00,0x41,0x7F,0x41,0x00},{0x20,0x40,0x41,0x3F,0x01},{0x7F,0x08,0x14,0x22,0x41},
  {0x7F,0x40,0x40,0x40,0x40},{0x7F,0x02,0x0C,0x02,0x7F},{0x7F,0x04,0x08,0x10,0x7F},{0x3E,0x41,0x41,0x41,0x3E},
  {0x7F,0x09,0x09,0x09,0x06},{0x3E,0x41,0x51,0x21,0x5E},{0x7F,0x09,0x19,0x29,0x46},{0x46,0x49,0x49,0x49,0x31},
  {0x01,0x01,0x7F,0x01,0x01},{0x3F,0x40,0x40,0x40,0x3F},{0x1F,0x20,0x40,0x20,0x1F},{0x3F,0x40,0x38,0x40,0x3F},
  {0x63,0x14,0x08,0x14,0x63},{0x07,0x08,0x70,0x08,0x07},{0x61,0x51,0x49,0x45,0x43},{0x00,0x7F,0x41,0x41,0x00},
  {0x02,0x04,0x08,0x10,0x20},{0x00,0x41,0x41,0x7F,0x00},{0x04,0x02,0x01,0x02,0x04},{0x40,0x40,0x40,0x40,0x40},
  {0x00,0x01,0x02,0x04,0x00},{0x20,0x54,0x54,0x54,0x78},{0x7F,0x48,0x44,0x44,0x38},{0x38,0x44,0x44,0x44,0x20},
  {0x38,0x44,0x44,0x48,0x7F},{0x38,0x54,0x54,0x54,0x18},{0x08,0x7E,0x09,0x01,0x02},{0x0C,0x52,0x52,0x52,0x3E},
  {0x7F,0x08,0x04,0x04,0x78},{0x00,0x44,0x7D,0x40,0x00},{0x20,0x40,0x44,0x3D,0x00},{0x7F,0x10,0x28,0x44,0x00},
  {0x00,0x41,0x7F,0x40,0x00},{0x7C,0x04,0x18,0x04,0x78},{0x7C,0x08,0x04,0x04,0x78},{0x38,0x44,0x44,0x44,0x38},
  {0x7C,0x14,0x14,0x14,0x08},{0x08,0x14,0x14,0x18,0x7C},{0x7C,0x08,0x04,0x04,0x08},{0x48,0x54,0x54,0x54,0x20},
  {0x04,0x3F,0x44,0x40,0x20},{0x3C,0x40,0x40,0x20,0x7C},{0x1C,0x20,0x40,0x20,0x1C},{0x3C,0x40,0x30,0x40,0x3C},
  {0x44,0x28,0x10,0x28,0x44},{0x0C,0x50,0x50,0x50,0x3C},{0x44,0x64,0x54,0x4C,0x44}
};

void sendOledCommand(TwoWire& bus, uint8_t cmd) {
  bus.beginTransmission(OLED_ADDR);
  bus.write(0x00); // Command byte
  bus.write(cmd);
  bus.endTransmission();
}

void initOled(TwoWire& bus) {
  // Standard SSD1306 128x64 startup sequence
  static const uint8_t cmds[] = {
    0xAE, 0xD5, 0x80, 0xA8, 0x3F, 0xD3, 0x00, 0x40,
    0x8D, 0x14, 0x20, 0x00, 0xA1, 0xC8, 0xDA, 0x12,
    0x81, 0xCF, 0xD9, 0xF1, 0xDB, 0x40, 0xA4, 0xA6, 0xAF
  };
  for (size_t i = 0; i < sizeof(cmds); i++) {
    sendOledCommand(bus, cmds[i]);
  }
}

void pushOledBuffer(TwoWire& bus, const uint8_t* buffer) {
  sendOledCommand(bus, 0x21); sendOledCommand(bus, 0); sendOledCommand(bus, 127);
  sendOledCommand(bus, 0x22); sendOledCommand(bus, 0); sendOledCommand(bus, 7);

  for (uint16_t i = 0; i < 1024; i += 16) {
    bus.beginTransmission(OLED_ADDR);
    bus.write(0x40); // Data byte
    for (uint8_t j = 0; j < 16; j++) {
      bus.write(buffer[i + j]);
    }
    bus.endTransmission();
  }
}

// Drawing Primitives
void drawPixel(uint8_t* fb, int x, int y, bool on) {
  if (x < 0 || x >= OLED_WIDTH || y < 0 || y >= OLED_HEIGHT) return;
  uint16_t idx = x + (y / 8) * OLED_WIDTH;
  uint8_t bit = 1 << (y & 7);
  if (on) fb[idx] |= bit;
  else    fb[idx] &= ~bit;
}

void drawLine(uint8_t* fb, int x0, int y0, int x1, int y1, bool on) {
  int dx = abs(x1 - x0), sx = x0 < x1 ? 1 : -1;
  int dy = -abs(y1 - y0), sy = y0 < y1 ? 1 : -1;
  int err = dx + dy;
  while (true) {
    drawPixel(fb, x0, y0, on);
    if (x0 == x1 && y0 == y1) break;
    int e2 = 2 * err;
    if (e2 >= dy) { err += dy; x0 += sx; }
    if (e2 <= dx) { err += dx; y0 += sy; }
  }
}

void drawText(uint8_t* fb, int x, int y, const char* str, bool on) {
  while (*str) {
    char c = *str++;
    if (c < 32 || c > 126) c = ' ';
    const uint8_t* glyph = FONT5x7[c - 32];
    for (int col = 0; col < 5; col++) {
      uint8_t b = pgm_read_byte(&glyph[col]);
      for (int row = 0; row < 7; row++) {
        if (b & (1 << row)) {
          drawPixel(fb, x + col, y + row, on);
        }
      }
    }
    x += 6;
  }
}

void setup() {
  Serial.begin(115200);
  delay(400);

  Serial.println("\n=======================================================");
  Serial.println("       Dual 0.96\" I2C OLED Test (Wire & Wire1)         ");
  Serial.println("=======================================================");

  // 1. Initialize Screen 1 on I2C Bus 0 (GPIO 11 SDA, GPIO 12 SCL)
  Wire.begin(S1_SDA, S1_SCL, 400000); // 400kHz fast I2C
  initOled(Wire);
  Serial.println("[OK] Screen 1 (Left: Parameters) initialized on Wire (GPIO 11/12).");

  // 2. Initialize Screen 2 on I2C Bus 1 (GPIO 10 SDA, GPIO 9 SCL)
  Wire1.begin(S2_SDA, S2_SCL, 400000); // 400kHz fast I2C
  initOled(Wire1);
  Serial.println("[OK] Screen 2 (Right: Visualizer) initialized on Wire1 (GPIO 10/9).");
}

static float g_phase = 0.0f;
static int g_val = 0;

void loop() {
  // Clear buffers
  memset(fb1, 0, sizeof(fb1));
  memset(fb2, 0, sizeof(fb2));

  // --- SCREEN 1: Groovebox Menu & Parameters ---
  // Yellow Header Zone (top 16 pixels)
  drawText(fb1, 4, 3, "TURING CO-PILOT", true);
  drawText(fb1, 100, 3, "120B", true);
  drawLine(fb1, 0, 14, 127, 14, true);

  // Blue Main Zone (lines 16 to 63)
  drawText(fb1, 4, 20, "[1] MUTATION : 45%", true);
  drawText(fb1, 4, 32, "[2] LENGTH   : 16", true);
  drawText(fb1, 4, 44, "[3] OCTAVE   : +1", true);
  drawText(fb1, 4, 55, "[4] FREEZE   : OFF", true);

  // Mini live bar
  int barW = (millis() / 40) % 120;
  for (int x = 4; x < 4 + barW; x++) {
    drawPixel(fb1, x, 63, true);
  }

  // --- SCREEN 2: Live Generative Waveform Visualizer ---
  drawText(fb2, 4, 3, "LIVE VISUALIZER", true);
  drawText(fb2, 102, 3, "[L]", true);
  drawLine(fb2, 0, 14, 127, 14, true);

  // Draw smooth 60 FPS sine / ripple wave across the blue area
  g_phase += 0.08f;
  for (int x = 0; x < 128; x++) {
    float yf = 38.0f + 16.0f * sinf(g_phase + x * 0.1f) * cosf(g_phase * 0.5f);
    int y = (int)yf;
    drawLine(fb2, x, 40, x, y, true);
  }

  // Push frames to both screens simultaneously
  pushOledBuffer(Wire, fb1);
  pushOledBuffer(Wire1, fb2);

  delay(20); // ~50 FPS buttery-smooth frame rate!
}
